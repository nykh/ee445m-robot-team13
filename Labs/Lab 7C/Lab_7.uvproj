# Keil uVision project Lab_7.uvproj, settings and files
target Lab_6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab_7
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\.. ; ..\inc\ ; ..\driverlib\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c SysTick.c io.c UART2.c OS.c osasm.s semaphore.c interpreter.c cr4_fft_64_stm32.s can0.c gpio_debug.c motor.c ir_sensor.c Ping.c myadc.c heap2.c atan.c lab7_main.c
  group Library
    ../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
